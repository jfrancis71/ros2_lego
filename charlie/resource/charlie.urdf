Commit message: Correcting frame link error on camera

File: charlie/resource/charlie.urdf (robot description, URDF)
Before this commit: robot myfirst, 3 links, 2 joints
Joints:
- joint base_to_camera: origin xyz=-0.06 0.0 0.095 rpy=0.0 1.6 0.0 -> xyz=0.06 0.0 0.095 rpy=0.0 1.6 0.0
